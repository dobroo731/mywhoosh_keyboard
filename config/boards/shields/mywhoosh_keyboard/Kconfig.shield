## config/boards/shields/mywhoosh_keyboard/Kconfig.shield
```kconfig
config SHIELD_MYWHOOSH_KEYBOARD
    def_bool $(shields_list_contains,mywhoosh_keyboard)
```
